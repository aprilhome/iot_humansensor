# IAR project Backup (4) of project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475RG ST STM32L475RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\rt-thread\code\rt-thread-4.0.1\components\libc\compilers\common; ..\..\rt-thread\code\rt-thread-4.0.1\components\finsh; ..\..\rt-thread\code\rt-thread-4.0.1\components\dfs\filesystems\elmfat; ..\..\rt-thread\code\rt-thread-4.0.1\components\libc\compilers\dlib; libraries\HAL_Drivers\config; libraries\HAL_Drivers; .; ..\..\rt-thread\code\rt-thread-4.0.1\libcpu\arm\cortex-m4; board; ..\..\rt-thread\code\rt-thread-4.0.1\components\drivers\include; board\CubeMX_Config\Inc; ..\..\rt-thread\code\rt-thread-4.0.1\libcpu\arm\common; board\ports; ..\..\rt-thread\code\rt-thread-4.0.1\components\dfs\include; libraries\STM32L4xx_HAL\CMSIS\Include; ..\..\rt-thread\code\rt-thread-4.0.1\components\drivers\spi; applications; libraries\HAL_Drivers\drv_flash; libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; ..\..\rt-thread\code\rt-thread-4.0.1\components\dfs\filesystems\devfs; libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; ..\..\rt-thread\code\rt-thread-4.0.1\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/code/rt-thread-4.0.1/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: api_gps.c api_pm.c api_sd.c api_temp.c api_timer.c drv_board.c main.c test.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_adc.c drv_rtc.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_l4.c
  group cpu
    ../../rt-thread/code/rt-thread-4.0.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/code/rt-thread-4.0.1/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/code/rt-thread-4.0.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/code/rt-thread-4.0.1/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/code/rt-thread-4.0.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/code/rt-thread-4.0.1/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/misc/: pin.c adc.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/rtc/: rtc.c alarm.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/serial/: serial.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c
    ../../rt-thread/code/rt-thread-4.0.1/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/code/rt-thread-4.0.1/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/code/rt-thread-4.0.1/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/code/rt-thread-4.0.1/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group STM32_HAL
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
